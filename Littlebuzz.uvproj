# Keil uVision project Littlebuzz.uvproj, settings and files
target Littlebuzz (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Littlebuzz +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Common\inc;.\Driver\inc;.\BSP;.\Startup;.\User
  group Common
    ./Common/src/: i2c.c imu.c led.c mpu6050.c nrf24l0102.c outputdata.c
  group Driver
    ./Driver/src/: adc.c delay.c EEPROM.C gpio.c iap.c pwm.c timer.c uart.c
  group Startup
    ./Startup/: STARTUP.A51
  group User
    ./User/: isr.c main.c includes.h func.c func.h simplekalman.c
  group BSP
    ./BSP/: IAP15W4K61S4.h IOConfig.h
